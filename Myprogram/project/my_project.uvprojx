# Keil uVision project my_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: ..\program\drivers;..\program;..\libraries\CMSIS;..\libraries\Drivers\src;..\libraries\Drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../libraries/CMSIS/: startup_stm32f40xx.s
  group CMSIS
    ../libraries/CMSIS/: system_stm32f4xx.c
    ../program/: stm32f4xx_conf.h
    ../libraries/Drivers/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c
  group Drivers
    ../program/drivers/: led.c usart.c pwm.c receive.c
  group Program
    ../program/: main.c stm32f4xx_it.c
